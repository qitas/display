# Keil uVision project 8051.uvproj, settings and files
target qitas (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: VCK1-1 +hex
  c flags: Optimize=6 SizeSpeed=1
  c include: ..\user
  group user
    ../user/: main.c ZK.c sys.c font.c LCD.c
