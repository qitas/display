# Keil uVision project CH552.uvproj, settings and files
target qitas (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: headset +hex
  c flags: Optimize=6 SizeSpeed=1
  group USER
    ./user/: main.c USB.c GPIO.C Timer.c LCD.c common.c font.c
