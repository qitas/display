# Keil uVision project 8051.uvproj, settings and files
target 8051 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: VCK1-1 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Display
    ./user/: main.c ZK.c
    ./SYS/: sys.c
    ./font/: font.c
    ./LCD/: LCD.c
